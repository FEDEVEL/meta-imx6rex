FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
 
SRC_URI += "file://0001-Initial-change-Board-name-change.patch"
SRC_URI += "file://0001-Memory-config-update.patch"
SRC_URI += "file://0001-Ethernet-init-update.patch"
